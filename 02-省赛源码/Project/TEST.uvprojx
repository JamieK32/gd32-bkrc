# Keil uVision project TEST.uvprojx, settings and files
target 2024_Competition (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c misc: --no-multibyte-chars
  c include: ..\USER;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\CMSIS;..\FreeRtos;..\FreeRtos\inc;..\FreeRtos\port;..\FreeRtos\src;..\FreeRtos\tasks;..\BSP\inc;..\Modules\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: gd32f4xx_it.c main.c task_manager.c button_callback.c rtc.c
  group BSP
    ../BSP/src/: iic.c usart.c timer.c adc.c delay.c
  group Modules
    ../Modules/src/: led.c rgb_led.c beep.c key.c bh1750.c hx711.c oled.c ch455g.c mpu6050.c rc522.c speak.c usart_lcd.c raspberryPi.c c1016.c c1016_cmds.c flame.c dht11.c ds18b20.c step_motor.c motor.c fan.c lock.c ultrasonic.c matrix.c matrix_data.c nixie.c alcohol.c smoke.c servo.c infrared_pyroelectric.c infrared_distance.c paj7620u2.c hmc5883l.c mlx90614.c rc522_port.c rc522_user.c
  group FreeRtos/inc
    ../FreeRtos/inc/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRtos/src
    ../FreeRtos/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRtos/port
    ../FreeRtos/port/: heap_4.c port.c
  group FreeRtos/conf
    ../FreeRtos/: FreeRTOSConfig.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
